# Keil uVision project Firmware_F411.uvprojx, settings and files
target Firmware (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Firmware_F411 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F411xE,ARM_MATH_CM4,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --preinclude stm32f4xx_conf.h --diag_suppress=767
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\CONFIG\interface;..\HARDWARE\interface;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP\interface;..\FLIGHT\interface;..\COMMON\interface;..\COMMUNICATE\interface;..\EXP_MODULES\interface
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../USER/: main.c
    ./: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CONFIG
    ../CONFIG/src/: config_param.c
    ../CONFIG/interface/: config.h config_param.h FreeRTOSConfig.h stm32f4xx_conf.h
  group HARDWARE
    ../HARDWARE/src/: ak8963.c bmp280.c module_detect.c exti.c iic1.c i2cdev.c i2c_drv.c led.c motors.c mpu6500.c myiic.c nvic.c uart_syslink.c uart1.c system.c stmflash.c watchdog.c ws2812.c
  group EXP_MODULES
    ../EXP_MODULES/src/: ledring12.c module_mgt.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../USB/USB_APP/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ../USB/USB_APP/interface/: usbd_cdc_vcp.h usbd_conf.h usb_conf.h
  group COMMUNICATE
    ../COMMUNICATE/src/: atkp.c comm.c commander.c ledseq.c console.c pm.c radiolink.c remoter_ctrl.c usblink.c wifi_ctrl.c
  group FLIGHT
    ../FLIGHT/src/: anomal_detec.c attitude_pid.c flip.c pid.c position_pid.c power_control.c sensfusion6.c sensors.c stabilizer.c state_control.c state_estimator.c
  group COMMON
    ../COMMON/src/: debug_assert.c freeRTOSdebug.c filter.c
  group README
    ../: readme.txt
